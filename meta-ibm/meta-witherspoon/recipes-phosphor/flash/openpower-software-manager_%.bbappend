PACKAGECONFIG_append_ibm-ac-server = " verify_pnor_signature"
PACKAGECONFIG_append_mihawk = " verify_pnor_signature"
PACKAGECONFIG_append_mowgli-server = " verify_pnor_signature"
