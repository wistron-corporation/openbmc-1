SRC_URI += "git://github.com/wistron-corporation/phosphor-networkd;branch=OP940"
SRCREV = "190431c2d9b5ff93c8bb3c0756c758eb9d47c086"
